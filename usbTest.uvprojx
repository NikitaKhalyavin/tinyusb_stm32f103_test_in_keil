# Keil uVision project usbTest.uvprojx, settings and files
target usbTest (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usbTest
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103xB
  c misc: --gnu
  c include: .\tinyusb\src;.\tinyusb\hw\mcu\st\cmsis_device_f1\Include;.\tinyusb\hw\mcu\st\stm32f1xx_hal_driver\Inc;.\;.\tinyusb\lib\CMSIS_5\CMSIS\Core\Include;.\tinyusb\hw;.\tinyusb\hw\bsp\stm32f103bluepill
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group tinyusb
    ./tinyusb/src/: tusb.c
    ./tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c
    ./tinyusb/src/device/: usbd.c usbd_control.c
    ./tinyusb/src/common/: tusb_fifo.c
    ./tinyusb/src/class/cdc/: cdc_device.c
    ./tinyusb/src/class/msc/: msc_device.c
  group cmsis
    ./tinyusb/hw/mcu/st/cmsis_device_f1/Source/Templates/: system_stm32f1xx.c
    ./tinyusb/hw/mcu/st/stm32f1xx_hal_driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_crc.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_tim.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group cdc_msc
    ./tinyusb/examples/device/cdc_msc/src/: main.c msc_disk.c usb_descriptors.c
    ./tinyusb/hw/bsp/: board.c
  group porting
    ./: stm32f103bluepill.c
    ./Objects/: startup_stm32f103xb.s
